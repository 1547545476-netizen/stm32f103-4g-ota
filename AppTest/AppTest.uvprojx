# Keil uVision project AppTest.uvprojx, settings and files
target AppTest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AppTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\Start;..\Library;..\User;..\System;..\Hardware;.\
  library: MicroLIB
  memory RVCT4: ROM 0x08005000 size 0x0000B000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../Library/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_iwdg.c
  group System
    ../System/: Delay.c
  group Hardware
    ../Hardware/: Serial.c Uart2.c Air780E.c Air780E_Mqtt.c OtaManifest.c OtaService.c MyI2C.c AT24C02.c MySPI.c W25Q64.c
  group App
    ./: main.c
